# Keil uVision project stm32f10x_led.uvproj, settings and files
target stm32f10x_led (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: stm32f10x_led
  c flags: Optim=1
  c include: ..\..\..\..\include;..\..\..\..\include\platform;..\..\..\..\include\hal;..\..\..\..\include\kernel;..\..\..\..\include\board;..\..\..\..\application;..\..\..\..\platform\stm32f10x\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\platform\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\platform\stm32f10x
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group kernel
    ../../../../kernel/: kernel.c
  group board
    ../../../../board/stm32f10x/demo_apps/led/: board.c
  group platform
    ../../../../platform/stm32f10x/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../../../platform/stm32f10x/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../platform/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../../platform/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group application
    ../../../../application/led/: led.c
